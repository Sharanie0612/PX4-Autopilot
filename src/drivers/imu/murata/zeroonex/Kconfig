## src/drivers/imu/murata/zeroonex/Kconfig
```kconfig
menuconfig DRIVERS_IMU_MURATA_ZEROONEX
	bool "ZEROONEX"
	default n
	---help---
		Enable support for murata ZeroOnex
```
